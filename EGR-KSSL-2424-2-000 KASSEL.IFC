Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Kassel\EGR-KSSL-2424-2-000 KASSEL.IFC
Time: 2024-11-26T11:19:36+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 160.9920000000001323; Volume Measure: 0.1609920000000002; Area Measure: 29.6496000000000315

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 160.9920000000001323; Volume Measure: 0.1609920000000002; Area Measure: 29.6496000000000315

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 160.9920000000001323; Volume Measure: 0.1609920000000002; Area Measure: 29.6496000000000315

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
EGR-KSSL-2424-2-000 KASSEL | PSet_Mass_Property - Mass Measure: 160.9920000000001323; Volume Measure: 0.1609920000000002; Area Measure: 29.6496000000000315
EGR-KSSL-2424-2-000 KASSEL
