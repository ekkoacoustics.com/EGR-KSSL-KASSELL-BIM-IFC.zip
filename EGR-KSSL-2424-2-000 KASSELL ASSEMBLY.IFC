Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Kassel\EGR-KSSL-2424-2-000 KASSELL ASSEMBLY.IFC
Time: 2024-12-17T14:39:52+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 161.5367296888713042; Volume Measure: 0.1615367296888725; Area Measure: 30.2408294312276489

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 161.5367296888713042; Volume Measure: 0.1615367296888725; Area Measure: 30.2408294312276489

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 161.5367296888713042; Volume Measure: 0.1615367296888725; Area Measure: 30.2408294312276489

# IfcBuildingElementProxy (205)
In: default BuildingStorey
Name
EGR-KSSL-2424-2-000 KASSELL ASSEMBLY | PSet_Mass_Property - Mass Measure: 161.5367296888713042; Volume Measure: 0.1615367296888725; Area Measure: 30.2408294312276489
H Section Hanging Extrusion + F000264 P50 Suspension Fitting
29 x H Section Hanging Extrusion - 100mm
29 x F000264 P50 SUSPENSION FITTING.SLDPRT
29 x F000264 P50 Top Threaded Insert
29 x F000264 P50 Clutch Fitting
29 x F000264 P50 M5 Threaded Bolt
29 x F000264 P50 Tensile Steel Wire 2m
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-1
EGR-KSSL-2424-2-000 KASSELL
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-2
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-3
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-4
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-5
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-6
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-7
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-8
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-9
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-10
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-11
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-12
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-13
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-14
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-15
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-16
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-17
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-18
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-19
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-20
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-21
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-22
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-23
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-24
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-25
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-26
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-27
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-28
