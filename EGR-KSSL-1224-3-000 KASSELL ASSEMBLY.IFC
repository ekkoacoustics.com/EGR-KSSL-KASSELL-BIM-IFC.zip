Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Kassel\EGR-KSSL-1224-3-000 KASSELL ASSEMBLY.IFC
Time: 2024-12-17T14:35:33+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 117.0081567356234586; Volume Measure: 0.1170081567356236; Area Measure: 21.4234083264970430

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 117.0081567356234586; Volume Measure: 0.1170081567356236; Area Measure: 21.4234083264970430

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 117.0081567356234586; Volume Measure: 0.1170081567356236; Area Measure: 21.4234083264970430

# IfcBuildingElementProxy (107)
In: default BuildingStorey
Name
EGR-KSSL-1224-3-000 KASSELL ASSEMBLY | PSet_Mass_Property - Mass Measure: 117.0081567356234586; Volume Measure: 0.1170081567356236; Area Measure: 21.4234083264970430
H Section Hanging Extrusion + F000264 P50 Suspension Fitting
15 x H Section Hanging Extrusion - 100mm
15 x F000264 P50 SUSPENSION FITTING.SLDPRT
15 x F000264 P50 Top Threaded Insert
15 x F000264 P50 Clutch Fitting
15 x F000264 P50 M5 Threaded Bolt
15 x F000264 P50 Tensile Steel Wire 2m
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-1
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-2
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-3
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-4
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-5
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-6
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-7
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-8
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-9
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-10
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-11
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-12
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-13
EGR-KSSL-1224-3-000 KASSELL
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-14
