Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Kassel\EGR-KSSL-1212-2-000 KASSEL.IFC
Time: 2024-11-26T11:22:23+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 74.9376000000000317; Volume Measure: 0.0749376000000000; Area Measure: 13.8672000000000022

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 74.9376000000000317; Volume Measure: 0.0749376000000000; Area Measure: 13.8672000000000022

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 74.9376000000000317; Volume Measure: 0.0749376000000000; Area Measure: 13.8672000000000022

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
EGR-KSSL-1212-2-000 KASSEL | PSet_Mass_Property - Mass Measure: 74.9376000000000317; Volume Measure: 0.0749376000000000; Area Measure: 13.8672000000000022
EGR-KSSL-1212-2-000 KASSEL
