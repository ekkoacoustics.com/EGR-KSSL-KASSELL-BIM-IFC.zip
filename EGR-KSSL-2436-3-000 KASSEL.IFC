Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Kassel\EGR-KSSL-2436-3-000 KASSEL.IFC
Time: 2024-11-26T11:14:14+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 370.2240000000001032; Volume Measure: 0.3702240000000002; Area Measure: 66.9095999999998554

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 370.2240000000001032; Volume Measure: 0.3702240000000002; Area Measure: 66.9095999999998554

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 370.2240000000001032; Volume Measure: 0.3702240000000002; Area Measure: 66.9095999999998554

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
EGR-KSSL-2436-3-000 KASSEL | PSet_Mass_Property - Mass Measure: 370.2240000000001032; Volume Measure: 0.3702240000000002; Area Measure: 66.9095999999998554
EGR-KSSL-2436-3-000 KASSEL
