Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Kassel\EGR-KSSL-1212-2-000 KASSELL ASSEMBLY.IFC
Time: 2024-12-17T14:30:39+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 75.1066540413740853; Volume Measure: 0.0751066540413742; Area Measure: 14.0506849958981963

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 75.1066540413740853; Volume Measure: 0.0751066540413742; Area Measure: 14.0506849958981963

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 75.1066540413740853; Volume Measure: 0.0751066540413742; Area Measure: 14.0506849958981963

# IfcBuildingElementProxy (65)
In: default BuildingStorey
Name
EGR-KSSL-1212-2-000 KASSELL ASSEMBLY | PSet_Mass_Property - Mass Measure: 75.1066540413740853; Volume Measure: 0.0751066540413742; Area Measure: 14.0506849958981963
EGR-KSSL-1212-2-000 KASSELL
H Section Hanging Extrusion + F000264 P50 Suspension Fitting
9 x H Section Hanging Extrusion - 100mm
9 x F000264 P50 SUSPENSION FITTING.SLDPRT
9 x F000264 P50 Top Threaded Insert
9 x F000264 P50 Clutch Fitting
9 x F000264 P50 M5 Threaded Bolt
9 x F000264 P50 Tensile Steel Wire 2m
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-1
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-2
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-3
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-4
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-5
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-6
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-7
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-8
