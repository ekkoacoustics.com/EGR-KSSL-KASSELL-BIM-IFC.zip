Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Kassel\EGR-KSSL-1224-3-000 KASSEL.IFC
Time: 2024-11-26T11:20:20+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 116.7263999999999555; Volume Measure: 0.1167264000000000; Area Measure: 21.1175999999999995

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 116.7263999999999555; Volume Measure: 0.1167264000000000; Area Measure: 21.1175999999999995

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 116.7263999999999555; Volume Measure: 0.1167264000000000; Area Measure: 21.1175999999999995

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
EGR-KSSL-1224-3-000 KASSEL | PSet_Mass_Property - Mass Measure: 116.7263999999999555; Volume Measure: 0.1167264000000000; Area Measure: 21.1175999999999995
EGR-KSSL-1224-3-000 KASSEL
