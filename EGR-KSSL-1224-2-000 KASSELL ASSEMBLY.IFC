Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Kassel\EGR-KSSL-1224-2-000 KASSELL ASSEMBLY.IFC
Time: 2024-12-17T14:34:15+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 78.0993567356234593; Volume Measure: 0.0780993567356237; Area Measure: 14.6530083264970017

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 78.0993567356234593; Volume Measure: 0.0780993567356237; Area Measure: 14.6530083264970017

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 78.0993567356234593; Volume Measure: 0.0780993567356237; Area Measure: 14.6530083264970017

# IfcBuildingElementProxy (107)
In: default BuildingStorey
Name
EGR-KSSL-1224-2-000 KASSELL ASSEMBLY | PSet_Mass_Property - Mass Measure: 78.0993567356234593; Volume Measure: 0.0780993567356237; Area Measure: 14.6530083264970017
H Section Hanging Extrusion + F000264 P50 Suspension Fitting
15 x H Section Hanging Extrusion - 100mm
15 x F000264 P50 SUSPENSION FITTING.SLDPRT
15 x F000264 P50 Top Threaded Insert
15 x F000264 P50 Clutch Fitting
15 x F000264 P50 M5 Threaded Bolt
15 x F000264 P50 Tensile Steel Wire 2m
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-1
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-2
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-3
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-4
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-5
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-6
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-7
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-8
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-9
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-10
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-11
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-12
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-13
EGR-KSSL-1224-2-000 KASSELL
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-14
