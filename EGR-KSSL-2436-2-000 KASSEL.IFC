Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Kassel\EGR-KSSL-2436-2-000 KASSEL.IFC
Time: 2024-11-26T11:15:19+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 246.8160000000003720; Volume Measure: 0.2468160000000002; Area Measure: 45.4608000000000985

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 246.8160000000003720; Volume Measure: 0.2468160000000002; Area Measure: 45.4608000000000985

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 246.8160000000003720; Volume Measure: 0.2468160000000002; Area Measure: 45.4608000000000985

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
EGR-KSSL-2436-2-000 KASSEL | PSet_Mass_Property - Mass Measure: 246.8160000000003720; Volume Measure: 0.2468160000000002; Area Measure: 45.4608000000000985
EGR-KSSL-2436-2-000 KASSEL
