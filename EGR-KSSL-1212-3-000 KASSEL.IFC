Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Kassel\EGR-KSSL-1212-3-000 KASSEL.IFC
Time: 2024-11-26T11:21:38+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 112.4064000000000192; Volume Measure: 0.1124064000000000; Area Measure: 20.4120000000000097

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 112.4064000000000192; Volume Measure: 0.1124064000000000; Area Measure: 20.4120000000000097

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 112.4064000000000192; Volume Measure: 0.1124064000000000; Area Measure: 20.4120000000000097

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
EGR-KSSL-1212-3-000 KASSEL | PSet_Mass_Property - Mass Measure: 112.4064000000000192; Volume Measure: 0.1124064000000000; Area Measure: 20.4120000000000097
EGR-KSSL-1212-3-000 KASSEL
