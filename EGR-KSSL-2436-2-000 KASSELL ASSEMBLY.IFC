Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Kassel\EGR-KSSL-2436-2-000 KASSELL ASSEMBLY.IFC
Time: 2024-12-17T14:38:42+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 247.3795134712464119; Volume Measure: 0.2473795134712474; Area Measure: 46.0724166529941854

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 247.3795134712464119; Volume Measure: 0.2473795134712474; Area Measure: 46.0724166529941854

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 247.3795134712464119; Volume Measure: 0.2473795134712474; Area Measure: 46.0724166529941854

# IfcBuildingElementProxy (212)
In: default BuildingStorey
Name
EGR-KSSL-2436-2-000 KASSELL ASSEMBLY | PSet_Mass_Property - Mass Measure: 247.3795134712464119; Volume Measure: 0.2473795134712474; Area Measure: 46.0724166529941854
H Section Hanging Extrusion + F000264 P50 Suspension Fitting
30 x H Section Hanging Extrusion - 100mm
30 x F000264 P50 SUSPENSION FITTING.SLDPRT
30 x F000264 P50 Top Threaded Insert
30 x F000264 P50 Clutch Fitting
30 x F000264 P50 M5 Threaded Bolt
30 x F000264 P50 Tensile Steel Wire 2m
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-1
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-2
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-3
EGR-KSSL-2436-2-000 KASSELL
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-4
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-5
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-6
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-7
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-8
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-9
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-10
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-11
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-12
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-13
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-14
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-15
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-16
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-17
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-18
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-19
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-20
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-21
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-22
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-23
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-24
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-25
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-26
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-27
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-28
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-29
