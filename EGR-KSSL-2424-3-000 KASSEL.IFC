Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Kassel\EGR-KSSL-2424-3-000 KASSEL.IFC
Time: 2024-11-26T11:18:46+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 241.4879999999999995; Volume Measure: 0.2414880000000000; Area Measure: 43.6391999999999527

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 241.4879999999999995; Volume Measure: 0.2414880000000000; Area Measure: 43.6391999999999527

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 241.4879999999999995; Volume Measure: 0.2414880000000000; Area Measure: 43.6391999999999527

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
EGR-KSSL-2424-3-000 KASSEL | PSet_Mass_Property - Mass Measure: 241.4879999999999995; Volume Measure: 0.2414880000000000; Area Measure: 43.6391999999999527
EGR-KSSL-2424-3-000 KASSEL
